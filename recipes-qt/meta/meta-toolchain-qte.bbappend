# Add suda SDK
TOOLCHAIN_TARGET_TASK_append = " packagegroup-suda-sdk-target"
