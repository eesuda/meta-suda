# Allows to avoid fetching, unpacking and patching, since our code is already cloned by repo
inherit externalsrc
